SUMMARY = "ISO639-2 support for Python"
DESCRIPTION = "A simple (really simple) library for working with ISO639-2 language codes."
HOMEPAGE = "https://github.com/janpipek/iso639-python"
SECTION = "devel/python"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=781266898051c8c67b123e089081aa4a"

SRC_URI[sha256sum] = "88b70cf6c64ee9c2c2972292818c8beb32db9ea6f4de1f8471a9b081a3d92e98"

inherit pypi python_setuptools_build_meta
